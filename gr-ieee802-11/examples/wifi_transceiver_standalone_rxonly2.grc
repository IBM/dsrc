<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_transceiver_standalone_rxonly2</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter</value></param>
<param><key>value</key><value>ieee802_11.signal_field()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_symbols</value></param>
<param><key>value</key><value>5 + 1 + ((16 + 1540 * 8 + 6) * 2) / 24</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_length</value></param>
<param><key>value</key><value>320</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>sync_length</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>16</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/augustojv/catkin_ws/src/era_gazebo/utils/receiver.out</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>wireless_noise.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/easisbot/catkin_ws/src/dsrc/gr-ieee802-11/examples/wireless_1000pkts_enc0.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/easisbot/catkin_ws/src/dsrc/gr-ieee802-11/examples/wireless_1000pkts_enc5.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/easisbot/catkin_ws/src/dsrc/gr-ieee802-11/examples/wireless_noise.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>encoding</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_1</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(64)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5890000000</value></param>
</block>
<block>
<key>ieee802_11_decode_mac</key>
<param><key>id</key><value>ieee802_11_decode_mac_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_frame_equalizer</key>
<param><key>id</key><value>ieee802_11_frame_equalizer_0</value></param>
<param><key>algo</key><value>chan_est</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_mac</key>
<param><key>id</key><value>ieee802_11_mac_0</value></param>
<param><key>bss_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>dst_mac</key><value>[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]</value></param>
<param><key>src_mac</key><value>[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_0</value></param>
<param><key>length</key><value>window_size + 16</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_1</value></param>
<param><key>length</key><value>window_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>msg_count</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>ros_interface_rate_debug</key>
<param><key>id</key><value>ros_interface_rate_debug_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>75</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sensitivity</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.56</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>strobe_period</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>ieee802_11_sync_long</key>
<param><key>id</key><value>sync_long</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sync_length</key><value>sync_length</value></param>
</block>
<block>
<key>ieee802_11_sync_short</key>
<param><key>id</key><value>sync_short</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>min_plateau</key><value>2</value></param>
<param><key>threshold</key><value>sensitivity</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>75</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>sync_long</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>sync_short</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>sync_short</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_1</source_block_id><sink_block_id>ieee802_11_frame_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_decode_mac_0</source_block_id><sink_block_id>ieee802_11_mac_0</sink_block_id><source_key>out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>ieee802_11_frame_equalizer_0</source_block_id><sink_block_id>ieee802_11_decode_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>app out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0</source_block_id><sink_block_id>ros_interface_rate_debug_0</sink_block_id><source_key>app out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_1</source_block_id><sink_block_id>sync_short</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sync_long</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_short</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_short</source_block_id><sink_block_id>sync_long</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
